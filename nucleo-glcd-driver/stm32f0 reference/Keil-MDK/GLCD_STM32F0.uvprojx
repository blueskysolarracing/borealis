# Keil uVision project GLCD_STM32F0.uvprojx, settings and files
target STM32F051R8 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GLCD_STM32F0
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX GLCD_DEVICE_STM32F0XX GLCD_CONTROLLER_PCD8544 GLCD_USE_SPI PCD8544_CONTRAST=80
  c include: ..\src\library\cmsis;..\src\library\drivers;..\src;..\src\library\glcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ../src/: main.c
  group cmsis
    ../src/library/cmsis/: startup_stm32f0xx.s system_stm32f0xx.c
  group peripheral_library
    ../src/library/drivers/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group GLCD
    ../src/library/glcd/: glcd.c graphics.c graphs.c text.c text_tiny.c unit_tests.c
    ../src/library/glcd/controllers/: PCD8544.c
    ../src/library/glcd/devices/: STM32F0xx.c
software components: CMSIS:CORE 5.0.0
